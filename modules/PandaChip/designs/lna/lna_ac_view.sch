v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {LNA AC response — verified: peak 54.0 dB @ 2.24 MHz, 53.8 dB @ 40-50 MHz, -3dB BW 22.4 kHz - 251 MHz} 40 -400 0 0 0.3 0.3 {layer=8}
B 2 40 -360 1000 -40 {flags=graph
rawfile=/home/irman/PandaChip/designs/lna/lna_final_ac.raw
sim_type=ac
autoload=1
color="4"
y1=0
y2=60
divy=6
x1=3
x2=9
divx=6
logx=1
unitx=1
node="gain_dB;out db20()"
}
